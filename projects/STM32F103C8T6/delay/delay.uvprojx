# Keil uVision project delay.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: delay +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Main;.\Startup;.\Library;.\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Main
    ./Main/: main.c stm32f10x_conf.h
  group Library
    ./Library/: stm32f10x_gpio.c stm32f10x_rcc.c
  group Startup
    ./Startup/: startup_stm32f10x_md.s system_stm32f10x.c system_stm32f10x.h stm32f10x.h core_cm3.c core_cm3.h
  group Include
    ./Include/: delay.c delay.h
